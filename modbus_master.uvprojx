# Keil uVision project modbus_master.uvprojx, settings and files
target modbus_master (6220000::V6.22::ARMCLANG)
  device: GD32F303VG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: build +hex
  AfterMake: fromelf --bin !L --output build\build.bin
  AfterMake: fromelf --text -a -c --output=build\build.dis build\build.axf
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F30X_XD
  c include: .\app;.\cdos;.\library\std_lib\inc;.\library;.\packages\cmbacktrace;.\packages\freemodbus-v1.6;.\packages\heap;.\packages\letter-shell-master\src;.\packages\multibutton;.\packages\umcn\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ./: main.c
  group cdos
    ./cdos/: cd_msg.c cd_schedule.c cd_service.c cd_task.c cd_timer.c
  group stdlib
    ./library/std_lib/src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group freemodbus
    ./packages/freemodbus-v1.6/: mb.c mbascii.c mbcrc.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbrtu.c mbtcp.c mbutils.c port.c portevent.c portserial.c porttimer.c
  group shell
    ./packages/letter-shell-master/src/: log.c shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group multibutton
    ./packages/multibutton/: multi_button.c
  group umcn
    ./packages/umcn/src/: uMCN.c
  group hw
    ./library/: systick.c system_gd32f30x.c startup_gd32f30x_xd.s gd32f30x_it.c
  group heap
    ./packages/heap/: heap_4.c
software components: CMSIS:CORE 6.1.0
